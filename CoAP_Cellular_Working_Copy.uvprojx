# Keil uVision project CoAP_Cellular_Working_Copy.uvprojx, settings and files
target CoAP_Cellular_Working_Copy (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: CoAP_Cellular_Working_Copy
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DNRF52_PAN_36 -DMBED_BUILD_TIMESTAMP=1503437908.33 -DNRF52_PAN_30 -DNRF52_PAN_31 --no_rtti --split_sections -g -c -DTARGET_NORDIC -DDEVICE_SERIAL_ASYNCH=1 --preinclude=mbed_config.h -DTARGET_MCU_NRF52 -DNRF52_PAN_20 -DDEVICE_I2C=1 -DTOOLCHAIN_ARM --no_depend_system_headers -DTOOLCHAIN_ARM_STD --md -DTARGET_LIKE_MBED --gnu -DTARGET_DEBUG -DFEATURE_COMMON_PAL=1 -DNRF52_PAN_62 -D__FPU_PRESENT=1 -DDEVICE_SPI_ASYNCH=1 -DDEVICE_RTC=1 -DNRF52_PAN_12 -DNRF52_PAN_15 -DCONFIG_GPIO_AS_PINRESET --restrict -D__ASSERT_MSG -DS132 -DDEVICE_ANALOGIN=1 -DDEVICE_LOWPOWERTIMER=1 -DSWI_DISABLE0 -DTARGET_UVISOR_UNSUPPORTED -DSOFTDEVICE_PRESENT --apcs=interwork -DTARGET_M4 -DFEATURE_BLE=1 -D__MBED_CMSIS_RTOS_CM -DTARGET_NRF5 -DBOARD_PCA10040 -DDEVICE_PORTINOUT=1 -DDEVICE_SERIAL_FC=1 -DTARGET_FF_ARDUINO -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 --multibyte_chars --cpu=Cortex-M4.fp -DDEVICE_PORTIN=1 -DBLE_STACK_SUPPORT_REQD -D__CORTEX_M4 --brief_diagnostics -DTARGET_NRF52_DK -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SERIAL=1 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DFEATURE_LOWPAN_ROUTER=1 -DDEVICE_I2C_ASYNCH=1 -DTARGET_RTOS_M4_M7 -DTARGET_LIKE_CORTEX_M4 -DARM_MATH_CM4 -DTARGET_CORTEX_M -DNRF52_PAN_63 -DDEVICE_ERROR_PATTERN=1 -DNRF52_PAN_64 -DTARGET_MCU_NRF52832 -DNRF52 -DDEVICE_PWMOUT=1 -DNRF52_PAN_54 -DNRF52_PAN_55 -DTARGET_NRF52832 -DNRF52_PAN_51 -DNRF52_PAN_53 -DNRF52_PAN_58 -DFEATURE_NANOSTACK=1
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DNRF52,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_58,-DNRF52_PAN_55,-DNRF52_PAN_54,-DARM_MATH_CM4,-DNRF52_PAN_30,-DNRF52_PAN_51,-DNRF52_PAN_36,-DNRF52_PAN_53,-DTARGET_NRF52832,-D__CORTEX_M4,-DNRF52_PAN_63,-DCONFIG_GPIO_AS_PINRESET,-DBLE_STACK_SUPPORT_REQD,-DSWI_DISABLE0,-DNRF52_PAN_20,-DNRF52_PAN_64,-DSOFTDEVICE_PRESENT,-DNRF52_PAN_62,-DS132,-DNRF52_PAN_31
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: None
  group CoAP_Cellular_Working_Copy
    ./: mbed_config.h
